FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-am335x-switch-U-Boot-console-to-UART1.patch \
"
